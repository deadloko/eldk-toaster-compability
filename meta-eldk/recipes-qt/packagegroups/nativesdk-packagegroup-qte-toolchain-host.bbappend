RDEPENDS_${PN} .= "\
	u-boot-mkimage-nativesdk \
	"

RDEPENDS_${PN}_append = "\
	kernel-dev	\
	u-boot-src	\
"

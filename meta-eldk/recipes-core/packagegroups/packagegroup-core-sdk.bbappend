RDEPENDS_${PN}_append = "	\
	cramfs			\
	dosfstools		\
	e2fsprogs		\
	e2fsprogs-e2fsck	\
	e2fsprogs-mke2fs	\
	e2fsprogs-tune2fs	\
	genext2fs		\
	kernel-dev		\
	mtd-utils		\
	mtd-utils-jffs2		\
	mtd-utils-misc		\
	mtd-utils-ubifs		\
	parted			\
	u-boot-mkimage		\
	u-boot-src		\
	"

RDEPENDS_${PN}_append = "\
	u-boot-mkimage-nativesdk \
	squashfs-tools-nativesdk \
	genext2fs-nativesdk \
	mtd-utils-nativesdk \
	mtd-utils-jffs2-nativesdk \
	mtd-utils-ubifs-nativesdk \
	mtd-utils-misc-nativesdk \
	util-linux-nativesdk \
	cramfs-nativesdk \
"

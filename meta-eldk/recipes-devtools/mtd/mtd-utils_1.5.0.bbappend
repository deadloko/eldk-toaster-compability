# add nativesdk feature

BBCLASSEXTEND += " nativesdk "

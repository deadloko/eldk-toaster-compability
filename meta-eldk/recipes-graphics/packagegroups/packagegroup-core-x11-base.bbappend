RDEPENDS_${PN}_append = "	\
	xinput-calibrator \
	"

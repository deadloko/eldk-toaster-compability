XSERVER_append = " xf86-input-tslib"

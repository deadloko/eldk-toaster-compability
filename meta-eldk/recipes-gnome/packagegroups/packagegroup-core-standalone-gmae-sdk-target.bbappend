RDEPENDS_${PN}_append = "	\
	cramfs			\
	dosfstools		\
	e2fsprogs		\
	e2fsprogs-e2fsck	\
	e2fsprogs-mke2fs	\
	e2fsprogs-tune2fs	\
        genext2fs		\
        mtd-utils		\
	parted			\
	u-boot-mkimage		\
	"
